## board/freescale/mx6qds/Kconfig
```kconfig
if TARGET_MX6QDS

config SYS_BOARD
	default "mx6qds"

config SYS_VENDOR
	default "freescale"

config SYS_CONFIG_NAME
	default "mx6qds"

endif
```
